Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-10-26T17:26:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.4.0.0 - Alternate UI 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 26 17:26:21 2021 * Host: DESKTOP-4UM54TC * Database: C:\Users\Vlad\AppData\Local\Temp\{F0AD06C5-44EC-4FCC-A312-B2BE0D688898}\ifc * Database version: 5507 * Database creation date: Tue Oct 26 17:26:21 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 26 17:26:21 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 26 17:26:21 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcFurnishingElement: Toolbox, Vitra-Home_Office-Toolbox:Toolbox:303778
In: Level 1
Type - Material: Mossy Grey
Type - General - Author: BIMStone; BIMObjectName: Vitra-Home_Office-Toolbox; ManufacterURL: https://www.vitra.com/en; ManufacturerName: Vitra; NBSDescription: Waste bins; NBSReference: 45-35-72/380; ProductInformation: The Toolbox by Arik Levy is designed as a practical organisational utensil for storing accessories and small items. Thanks to its handy size, it can be easily stowed in a cabinet or on a shelf, and it takes up little room on a table. The Toolbox is available in a selection of different colours.; Revision: n/a; Uniclass2: Pr_40_70_22_92; Uniclass2015Description: Tool dispensers; Uniclass2015Reference: Pr_40_70_22_92; Version: 1; VersionDate: 22/10/2021
Type - Identity Data - Cost: 0; Description: The Toolbox by Arik Levy is designed as a practical organisational utensil for storing accessories and small items. Thanks to its handy size, it can be easily stowed in a cabinet or on a shelf, and it takes up little room on a table. The Toolbox is available in a selection of different colours.; Designer: Arik Levy; Manufacturer: Vitra; Model: Toolbox; OmniClass Number: 23.40.20.31; OmniClass Title: Refuse Disposal Furniture; Type Name: Toolbox; URL: https://www.vitra.com/en-pl/living/product/details/toolbox
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Home_Office-Toolbox; Features: n/a; Finish: n/a; Grade: n/a; Material: ABS plastic; ModelNumber: 89255021; ModelReference: n/a; Name: Toolbox; ReplacementCost: n/a; Shape: Sculptured; Size: 300x300x375 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.131673 m2; Volume: 0.008519 m3
Materials and Finishes - ColorMaterial: Mossy Grey
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Vitra-Home_Office-Toolbox: Toolbox; Family and Type: Vitra-Home_Office-Toolbox: Toolbox; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Home_Office-Toolbox: Toolbox; Type Id: Vitra-Home_Office-Toolbox: Toolbox; WarrantyStartDate: n/a
Phasing - Phase Created: Phase 1
